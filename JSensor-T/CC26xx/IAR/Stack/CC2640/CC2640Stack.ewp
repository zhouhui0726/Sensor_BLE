# IAR project CC2640Stack.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2640F128 TexasInstruments CC2640F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: OSAL_SNV=1; USE_ICALL; FLASH_ROM_BUILD; OSAL_MAX_NUM_PROXY_TASKS=5; POWER_SAVING; GATT_NO_CLIENT; INCLUDE_AES_DECRYPT; xPM_DISABLE_PWRDOWN; xTESTMODES; xTEST_BLEBOARD; OSAL_CBTIMER_NUM_TASKS=1; xDEBUG; HALNODEBUG; xDEBUG_GPIO; xDEBUG_ENC; xDEBUG_SW_TRACE; NEAR_FUNC=; DATA=; CC26XXWARE; CC26XX
  ICCARM.IExtraOptions: --aeabi; -f ..\..\..\..\..\..\..\Projects\ble\config\buildComponents.opt; -f buildConfig.opt; -f ..\..\Config\IAR-Boundary.bdef
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Source/Stack; ../../../../../../../Projects/ble/Include; ../../../../../../../Projects/ble/common/cc26xx; ../../../../../../../Components/hal/target/CC2650TIRTOS; ../../../../../../../Components/hal/target/_common/cc26xx; ../../../../../../../Components/hal/include; ../../../../../../../Components/osal/include; ../../../../../../../Components/services/nv/cc26xx; ../../../../../../../Components/services/nv; ../../../../../../../Components/services/saddr; ../../../../../../../Components/icall/include; ../../../../../../../Components/ble/include; ../../../../../../../Components/ble/controller/CC26xx/include; ../../../../../../../Components/ble/ROM; ../../../../../../../Components/ble/hci; ../../../../../../../Components/ble/host; ../../../../../../../Components/services/aes/CC26xx; ../../../../../../../Components/npi; ../../../../../../../Projects/ble/common/npi/npi_np/CC26xx/Stack; ../../../../../../../Projects/ble/Include; ../../../../../../../Projects/ble/ICall/Include; ../../../../../../../Projects/ble/Profiles/Roles; ../../../../../../../Components/ble/controller/CC26xx/CM0_Patch; $CC26XXWARE$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SimpleBLEPeripheralStackFlashROM.hex
  prebuild: ..\..\..\..\..\..\tools\LibSearch\libSearch.exe buildConfig.opt ..\..\..\..\..\..\tools\LibSearch\parameters.xml ..\..\..\..\..\Libraries\CC26xx\IAR\ ..\..\Lib\$PROJ_FNAME$.a FlashROM
  postbuild: $BOUNDARY$\Boundary.exe -chip "CC2640" -prj "iar" -lcf "..\..\..\..\..\common\cc26xx\IAR\cc26xx_ble_stack.icf" -map "$CONFIG_NAME$\List\SimpleBLEPeripheralStackFlashROM.map" -xml "..\..\..\..\..\..\..\Projects\ble\common\cc26xx\Boundary\BoundaryConfig.xml" -cc "..\..\Config\IAR-Boundary.bdef" -lnk "..\..\Config\IAR-Boundary.xcl" -log "..\..\Config\Boundary.log"
  ILINK.IlinkOutputFile: SimpleBLEPeripheralStackFlashROM.out
  ILINK.IlinkConfigDefines: FLASH_ROM_BUILD=1; CC2650=1
  ILINK.IlinkIcfFile: ..\..\..\..\..\common\cc26xx\IAR\cc26xx_ble_stack.icf
  ILINK.IlinkExtraOptions: -f ..\..\Config\IAR-Boundary.xcl
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\common\BLE_ROM_Releases\04242014\ble_rom_PATCH.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: startup_entry
configuration FlashROM_4x4 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: USE_ICALL; FLASH_ROM_BUILD; POWER_SAVING; GATT_NO_CLIENT; INCLUDE_AES_DECRYPT; xPM_DISABLE_PWRDOWN; xTESTMODES; xTEST_BLEBOARD; OSAL_CBTIMER_NUM_TASKS=1; xDEBUG; HALNODEBUG; xDEBUG_GPIO; xDEBUG_ENC; xDEBUG_SW_TRACE; NEAR_FUNC=; DATA=; CC26XXWARE; CC26XX
  group HAL/Common
    ../../../../../../../Components/hal/common/: hal_assert.c
  group HAL/Include
    ../../../../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2650/_common
    ../../../../../../../Components/hal/target/CC2650TIRTOS/: hal_mcu.h
    ../../../../../../../Components/hal/target/_common/cc26xx/: mb_PATCH.c
  group HAL/Target/CC2650/Config
    ../../../../../../../Components/hal/target/CC2650TIRTOS/: hal_board_cfg.h
  group HAL/Target/CC2650/Drivers
    ../../../../../../../Components/hal/target/CC2650TIRTOS/: hal_flash_wrapper.c hal_rtc_wrapper.h hal_trng_wrapper.c hal_trng_wrapper.h
  group ICallBLE
    ../../../../../ICall/Stack/: bleDispatch.c
    ../../../../../ICall/Include/: bleDispatch.h
  group INCLUDE
    ../../../../../../../Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../../../../../../Components/ble/host/: linkdb.h
    ../../../../../../../Components/ble/controller/CC26xx/include/: ll.h
  group LIB
    ../../Lib/: CC2640Stack.a CC2640Stack_HCI_TL.a
  group NPI
    ../../../../../common/npi/npi_np/CC26xx/Stack/: npi.c
    ../../../../../common/npi/npi_np/CC26xx/Include/: npi.h
  group OSAL
    ../../../../../../../Components/osal/include/: comdef.h OSAL.h osal_bufmgr.h osal_cbtimer.h OSAL_Clock.h OSAL_Memory.h OSAL_PwrMgr.h osal_snv.h osal_task.h OSAL_Timers.h
    ../../../../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_Clock.c OSAL_MemoryICall.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../../../../Components/osal/mcu/cc26xx/: osal_snv_wrapper.c
  group PROFILES
    ../../../../../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h
    ../../../../../Profiles/GATT/: gattservapp_util.c
  group Startup
    ../../../../../ICall/Stack/: bleUserConfig.c
    ../../../../../../../Components/ble/ROM/: CommonROM_Init.c ROM_Init.c
    ../../../../../common/cc26xx/: ICall_startup.c
    ../../../Source/Stack/: OSAL_ICallBle.c
  group TOOLS
    ../../../../../config/: buildComponents.opt
    ./: buildConfig.opt
    ../../../../../common/cc26xx/IAR/: cc26xx_ble_stack.icf
    ../../Config/: IAR-Boundary.bdef IAR-Boundary.xcl
    ../../../../../common/cc26xx/: OnBoard.c OnBoard.h
