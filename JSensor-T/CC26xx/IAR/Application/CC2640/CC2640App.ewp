# IAR project CC2640App.ewp, settings and files
configuration FlashROM_SW (ARM, debug)
  General.OGChipSelectEditMenu: CC2640F128 TexasInstruments CC2640F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_ICALL; POWER_SAVING; HEAPMGR_SIZE=3500; ICALL_MAX_NUM_TASKS=4; ICALL_MAX_NUM_ENTITIES=7; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; CC26XXWARE; CC26XX; PLUS_BROADCASTER; APP_HANDSHAKE_ENABLE; xAPP_CONTROL_ENABLE; NPI_USE_UART; xUART_PRINT_ENABLE; TI_DRIVERS_SPI_DMA_INCLUDED; TI_DRIVERS_LORA_ENABLE; LORA_WAN_ENABLE; USE_MD5; USE_PTM
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f ..\..\..\..\..\..\..\Projects\ble\config\buildComponents.opt; -f configPkg\compiler.opt.defs; -f ..\..\Config\IAR-Boundary.bdef
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Source/Application; ../../../../../../../Projects/ble/Include; ../../../../../../../Projects/ble/ICall/Include; ../../../../../../../Projects/ble/Profiles/Roles/CC26xx; ../../../../../../../Projects/ble/Profiles/Roles; ../../../../../../../Projects/ble/common/cc26xx; ../../../../../../../Components/applib/heap; ../../../../../../../Components/ble/hci; ../../../../../../../Components/ble/controller/CC26xx/include; ../../../../../../../Components/ble/host; ../../../../../../../Components/hal/target/CC2650/rom; ../../../../../../../Components/hal/target/CC2650TIRTOS; ../../../../../../../Components/hal/target/_common/cc26xx; ../../../../../../../Components/hal/include; ../../../../../../../Components/osal/include; ../../../../../../../Components/services/sdata; ../../../../../../../Components/services/saddr; ../../../../../../../Components/icall/include; ../../../../../../../Components/ble/include; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; ..\..\Interfaces\Profile\CC26xx; ..\..\Interfaces\Profile; ..\..\Interfaces\boards\SRF06EB\CC2650EM_7ID; ..\..\Interfaces\Roles\CC26xx; ..\..\Interfaces\driver; ..\..\Interfaces\driver\npi; ..\..\Interfaces\driver\npi\unified\inc; ..\..\Interfaces\ICall\Include; ..\..\..\Source\Application\loraWAN; ..\..\..\Source\Application\loraWAN\loramac\mac; ..\..\..\Source\Application\loraWAN\loramac\node; ..\..\..\Source\Application\loraWAN\sx1278
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: JC_BLEPeripheralAppFlashROM.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: JC_BLEPeripheralAppFlashROM.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\common\cc26xx\IAR\cc26xx_ble_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f configPkg\linker.cmd; -f ..\..\Config\IAR-Boundary.xcl
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib; $TI_RTOS_DRIVERS_BASE$\ti\drivers\lib\drivers_cc26xxware.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../Source/Application/: JC_BLEPeripheral.c JC_BLEPeripheral.h
    ../../../../../common/cc26xx/: util.c util.h
  group Drivers/CRC
    ../../Interfaces/driver/: AskCrc.c
  group Drivers/LORAWAN
    ../../../Source/Application/loraWAN/: lorawan_node.c lorawan_node.h
  group Drivers/LORAWAN/MAC
    ../../../Source/Application/loraWAN/loramac/mac/: caes.c caes.h cmac.c cmac.h Comissioning.h LoRaMac-board.h LoRaMac.c LoRaMac.h LoRaMacCrypto.c LoRaMacCrypto.h LoRaMacTest.h
    ../../../Source/Application/loraWAN/loramac/node/: lboard.c lboard.h sx1278-board.c sx1278-board.h utilities.c utilities.h
  group Drivers/LORAWAN/SX1278
    ../../../Source/Application/loraWAN/sx1278/: radio.h sx1278-Fsk.c sx1278-Fsk.h sx1278-FskMisc.c sx1278-FskMisc.h sx1278.c sx1278.h sx1278Regs-Fsk.h sx1278Regs-LoRa.h
  group Drivers/MD5
    ../../Interfaces/driver/: md5_new.c md5_new.h
  group Drivers/NPI/HW
    ../../Interfaces/driver/npi/: npi_rxbuf.c npi_tl.c npi_tl_uart.c tl.c
  group Drivers/NPI/SW
    ../../Interfaces/driver/npi/unified/: npi_task_swhs.c npi_tl_swhs.c npi_tl_uart_swhs.c npi_util.c
  group Drivers/PIN
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: PIN.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/PRINTF
    ../../Interfaces/driver/: uart_printf.c uart_printf.h
  group Drivers/SENSOR
    ../../Interfaces/driver/: temperature_sensor.c temperature_sensor.h
  group Drivers/SPI
    ../../Interfaces/driver/: bsp_spi.c bsp_spi.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: SPI.c SPI.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/spi/: SPICC26XXDMA.c SPICC26XXDMA.h
  group Drivers/UART
    ../../Interfaces/driver/: UartDataProcess.c UartDataProcess.h
  group Drivers/UDMA
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/dma/: UDMACC26XX.c UDMACC26XX.h
  group ICall
    ../../../../../../../Components/applib/heap/: heapmgr.h
    ../../../../../../../Components/icall/ports/tirtos/: ICall.c ICallCC2650.c ICallPlatform.h
    ../../../../../../../Components/icall/include/: ICall.h
    ../../../../../../../Components/hal/target/CC2650TIRTOS/: ICallAddrs.h
  group ICallBLE
    ../../../../../ICall/Application/: bleUserConfig.c ICallBleAPI.c
    ../../Interfaces/ICall/Include/: bleUserConfig.h
    ../../../../../ICall/Include/: ICallBleAPIMSG.h
  group Include
    ../../../../../../../Components/ble/include/: gap.h gatt.h hci.h
    ../../../../../Profiles/Roles/: gapbondmgr.h
    ../../../../../Include/: gapgattserver.h
    ../../../../../../../Components/osal/include/: osal_snv.h
  group PROFILES
    ../../Interfaces/Profile/CC26xx/: app_control_service.c app_control_service.h app_handshake_service.c app_handshake_service.h JC_GATTprofile.c
    ../../../../../Include/: gatt_profile_uuid.h
    ../../../../../../../Components/ble/host/: gatt_uuid.c
    ../../../../../../../Components/ble/include/: gatt_uuid.h
    ../../../../../Profiles/GATT/: gattservapp_util.c
    ../../Interfaces/Profile/: JC_GATTprofile.h
    ../../Interfaces/Roles/CC26xx/: JC_peripheral.c JC_peripheral.h
  group Startup
    ../../Interfaces/boards/SRF06EB/: Board.c
    ../../Config/: ccfg_appBLE.c
    ../../../Source/Application/: main.c
  group TOOLS
    ../../Config/: appBLE.cfg IAR-Boundary.bdef IAR-Boundary.xcl
    ../../../../../common/cc26xx/IAR/: cc26xx_ble_app.icf cc26xx_ble_app_oad.icf
